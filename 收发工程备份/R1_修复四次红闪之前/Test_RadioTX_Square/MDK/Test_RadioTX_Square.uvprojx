# Keil uVision project Test_RadioTX_Square.uvprojx, settings and files
target Test_RadioTX_Square (6180000::V6.18::ARMCLANG)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(16000000) ELITTLE
  output: Test_RadioTX_Square +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=5
  c define: USE_STDPERIPH_DRIVER,STM32L1XX_MD
  c misc: -std=c99 -Wall -Wextra
  c include: ..\User;..\CMSIS\Device\Include;..\CMSIS\Include;..\STM32L1xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Startup
    ./: startup_stm32l1xx_md.s
  group Application
    ../User/: main.c board.c radio_link.c link_protocol.c sound.c
  group STM32 peripheral library
    ../STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_spi.c stm32l1xx_pwr.c stm32l1xx_flash.c stm32l1xx_tim.c
