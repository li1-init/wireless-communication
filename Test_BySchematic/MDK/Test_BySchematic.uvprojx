# Keil uVision project Test_BySchematic.uvprojx, settings and files
target Test_BySchematic (6180000::V6.18::ARMCLANG)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Test_BySchematic +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=5
  c define: USE_STDPERIPH_DRIVER,STM32L1XX_MD
  c misc: -std=c99
  c include: ..\CMSIS\Device\ST\STM32L1xx\Include;..\CMSIS\Include;..\STM32L1xx_StdPeriph_Driver\inc;..\SI4438;..\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Startup
    ./: startup_stm32l1xx_md.s
  group CMSIS
    ../CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group STM32L1xx_StdPeriph_Driver
    ../STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group SI4438
    ../SI4438/: radio.c radio_comm.c radio_hal.c si446x_api_lib.c
  group Application
    ../User/: main.c app_state.c app_events.c app_protocol.c app_radio.c led.c device_uid.c stm32l1xx_it.c
  group Platform
    ../User/: User_STM32Lxx_Peripheral.c
software components: CMSIS:CORE 5.6.0
